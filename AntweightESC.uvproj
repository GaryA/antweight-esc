# Keil uVision project AntweightESC.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: Simulation +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SIMULATION
  c include: .\Targets\Generic
  group Source
    ./: STARTUP.A51 main.c init.c motor.c
target HobbyWingFlyFun6A (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: HobbyWingFlyFun6A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Targets\HobbyWingFlyFun6A
target Generic (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: Generic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Targets\Generic
